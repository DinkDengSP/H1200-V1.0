<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\ProjectCollection\C21_InterfaceMainControl\ProjectFiles\C21_InterfaceMainControl.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\ProjectCollection\BootLoader\ProjectFiles\H360_MidCommBoard_BootLoader.ewp</path>
    </project>
    <batchBuild />
</workspace>
