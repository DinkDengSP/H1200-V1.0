<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\BootLoader\ProjectFiles\BootLoader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\MultiRail_MainControlBoard\ProjectFiles\MultiRailMainControlApp.ewp</path>
    </project>
    <batchBuild />
</workspace>
