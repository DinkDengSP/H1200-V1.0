<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AppDemo\ProjectFiles\AppDemo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Boot\ProjectFiles\BootLoader.ewp</path>
    </project>
    <batchBuild />
</workspace>
