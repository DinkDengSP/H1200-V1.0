<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\BootLoader\ProjectFiles\BootLoader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\H360_MainControlBoard\ProjectFiles\H360_NetMainControlBoard.ewp</path>
    </project>
    <batchBuild />
</workspace>
