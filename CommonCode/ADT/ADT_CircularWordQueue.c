/*********************************************************************************************** 
** Author        : DengXiaoJun(邓小俊)
** Date          : 2023-02-14 13:06:57 +0800
** Description   : When I Has Time ,I Will Write Description Below:
** ModifyRecord1 :    
** ModifyRecord2 :    
** LastEditors   : DengXiaoJun(邓小俊)
** LastEditTime  : 2023-02-27 13:35:03 +0800
************************************************************************************************/ 
#include "ADT_CircularWordQueue.h"

//宏定义结构体类型,这种定义的好处是不用出现大量的各种类型名,代码整洁
//理解上差点意思,但是使用者不需要太了解内部结构
#define ADT_T ADT_CIRCULAR_WORD_QUEUE_T
//结构体的类型ID,用于程序运行时的检查
//_COUNTER_  一个从0开始的全局的计数器，每次用于源文件或在源文件中被引用头文件时，自动加1
#define ADT_CIRCULAR_WORD_QUEUE_T_ID         0X20200714

//结构体定义
struct ADT_T 
{
    //函数指针
    ADT_MemMallocFuncPtr memMallocFunc;
    ADT_MemFreeFuncPtr memFreeFunc;
    ADT_LockSystem sysLockFunc;
    ADT_UnLockSystem sysUnlockFunc;
    ADT_SendString sendStrFunc;
    //识别ID
    uint32_t adtTypeID;
    //数据定义
    uint16_t *queueArrayBuffer; //循环队列缓冲区
    uint16_t frontPos;         //循环队列头,下一次取数据从该位置去取
    uint16_t rearPos;          //循环队列位,插入数据的时候看这个数据
    uint16_t maxSize;          //队列最大容量
    uint16_t currentSize;      //当前有效数据长度
    //满载操作
    ADT_FULL_OPTION fullOption;
};

//循环队列初始化,这里的ADT是一个数据类型,是H文件中定义的指向ADT_CIRCULAR_WORD_QUEUE_T的指针
ADT_T ADT_CircularWordQueueCreate(uint16_t bufferSize,ADT_FULL_OPTION fullOption,ADT_MemMallocFuncPtr memMallocFunc,ADT_MemFreeFuncPtr memFreeFunc,
                                ADT_LockSystem lockSysFuncPtr,ADT_UnLockSystem unlockSysFuncPtr,ADT_SendString sendStrFunc)
{
    //ADT系统锁定前置
    ADT_SYS_LOCK_ALLOC(lastState);
    //回调函数检查
    ADT_CALL_BACK_CHECK(ADT_CircularWordQueueCreate,memMallocFunc,memFreeFunc,lockSysFuncPtr,unlockSysFuncPtr,sendStrFunc);
    //参数检查
    if(bufferSize == 0)
    {
        sendStrFunc("Error!! ADT_CircularWordQueueCreate bufferSize 0!!\r\n");
        return NULL;
    }
    //定义实体
    ADT_T circularWordQueuePtr = NULL;
    //实体内存申请
    ADT_MALLOC_SELF(circularWordQueuePtr,memMallocFunc);
    //函数映射
    ADT_CALL_BACK_REGISTER(circularWordQueuePtr,memMallocFunc,memFreeFunc,lockSysFuncPtr,unlockSysFuncPtr,sendStrFunc);
    //数据缓存申请
    circularWordQueuePtr->queueArrayBuffer = (uint16_t*)ADT_MEM_MALLOC(circularWordQueuePtr,bufferSize*sizeof(uint16_t));
    //系统锁定
    ADT_SYS_LOCK(circularWordQueuePtr);
    //数据复位
    circularWordQueuePtr->frontPos = 0;
    circularWordQueuePtr->rearPos = 0;
    circularWordQueuePtr->maxSize = bufferSize;
    circularWordQueuePtr->currentSize = 0;
    //满载操作
    circularWordQueuePtr->fullOption = fullOption;
    //功能辅助
    ADT_SET_IDENTIFY_CODE_SET(circularWordQueuePtr,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    //系统解锁
    ADT_SYS_UNLOCK(circularWordQueuePtr);
    //返回结构体指针
    return circularWordQueuePtr;
}

//释放申请的内存
void ADT_CircularWordQueueFree(ADT_T* circularWordQueuePtrPtr)
{
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtrPtr,ADT_CircularWordQueueFree);
    //定义实体
    ADT_T circularWordQueuePtr = (*circularWordQueuePtrPtr);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueFree,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    //释放缓存
    ADT_MEM_FREE(circularWordQueuePtr,circularWordQueuePtr->queueArrayBuffer);
    //释放自身
    ADT_FREE_SELF(circularWordQueuePtr);
    return;
}

//获取循环队列最大容量
uint16_t ADT_CircularWordQueueGetMaxCapacity(ADT_T circularWordQueuePtr)
{
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtr,ADT_CircularWordQueueGetMaxCapacity);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueGetMaxCapacity,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    //容量返回
    return circularWordQueuePtr->maxSize;
}

//获取当前循环队列已经存储的数据
uint16_t ADT_CircularWordQueueGetCurrentSize(ADT_T circularWordQueuePtr)
{
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtr,ADT_CircularWordQueueGetCurrentSize);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueGetCurrentSize,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    //当前尺寸返回
    return circularWordQueuePtr->currentSize;
}

//获取当前循环队列中空数据的量
uint16_t ADT_CircularWordQueueGetCurrentEmptySize(ADT_T circularWordQueuePtr)
{
    //ADT系统锁定前置
    ADT_SYS_LOCK_ALLOC(lastState);
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtr,ADT_CircularWordQueueGetCurrentEmptySize);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueGetCurrentEmptySize,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    uint16_t emptySize = 0;
    //系统锁定
    ADT_SYS_LOCK(circularWordQueuePtr);
    //计算
    emptySize = circularWordQueuePtr->maxSize - circularWordQueuePtr->currentSize;
    //系统解锁
    ADT_SYS_UNLOCK(circularWordQueuePtr);
    return emptySize;
}

//往循环队列中写入指定数量数据,满载分为两种情况,弹出旧数据或者拒绝新数据
void ADT_CircularWordQueueWriteBuffer(ADT_T circularWordQueuePtr,uint16_t* bufferWritePtr,uint16_t length,uint16_t* realWriteByteCount)
{
    //ADT系统锁定前置
    ADT_SYS_LOCK_ALLOC(lastState);
    uint16_t writeCount = 0;
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtr,ADT_CircularWordQueueWriteBuffer);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueWriteBuffer,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    //参数检查
    if(bufferWritePtr == NULL)
    {
        ADT_SHOW_STR(circularWordQueuePtr,"Error!! ADT_CircularWordQueueWriteBuffer bufferWritePtr NULL!!\r\n");
        *realWriteByteCount = 0;
        return;
    }
    //系统锁定
    ADT_SYS_LOCK(circularWordQueuePtr);
    //写入之前先检查是否满载
    if((circularWordQueuePtr->fullOption == ADT_FULL_OPTION_BLOCK)&&
            (circularWordQueuePtr->maxSize == circularWordQueuePtr->currentSize))
    {
        //当前数据已满,不再写入
        *realWriteByteCount = 0;
        //系统解锁
        ADT_SYS_UNLOCK(circularWordQueuePtr);
        return;
    }
    //数据写入
    for(writeCount = 0;writeCount < length;writeCount++)
    {
        //检查是否写满了,并且设置将旧数据弹出
        if((circularWordQueuePtr->maxSize == circularWordQueuePtr->currentSize)&&
                (circularWordQueuePtr->fullOption == ADT_FULL_OPTION_POP))
        {
            //队列头减小
            circularWordQueuePtr->frontPos++;
            //控制不能溢出
            circularWordQueuePtr->frontPos %= circularWordQueuePtr->maxSize;
            //当前尺寸缩一个
            circularWordQueuePtr->currentSize -= 1;;
        }
        //数据写入
        circularWordQueuePtr->queueArrayBuffer[circularWordQueuePtr->rearPos++] = bufferWritePtr[writeCount];
        circularWordQueuePtr->rearPos %= circularWordQueuePtr->maxSize;
        circularWordQueuePtr->currentSize++;
        //写入数量增加
        *realWriteByteCount += 1;
        //检查满载并且设置堵塞
        if((circularWordQueuePtr->fullOption == ADT_FULL_OPTION_BLOCK)&&
            (circularWordQueuePtr->maxSize == circularWordQueuePtr->currentSize))
        {
            break;
        }
    }
    //系统解锁
    ADT_SYS_UNLOCK(circularWordQueuePtr);
    return;
}

//往循环队列中写入单个字数据
ADT_RESULT ADT_CircularWordQueueWriteOnce(ADT_T circularByteQueuePtr,uint16_t wordWrite)
{
    uint16_t readWriteByte = 0;
    ADT_CircularWordQueueWriteBuffer(circularByteQueuePtr,&wordWrite,1,&readWriteByte);
    if(readWriteByte == 0)
    {
        return ADT_RESULT_FAIL;
    }
    return ADT_RESULT_OK;
}

//从循环队列中读取指定数量数据,当数据不足时,已有的数据写到缓冲区,并返回真实读取到的数据
void ADT_CircularWordQueueReadBuffer(ADT_T circularWordQueuePtr,uint16_t* bufferReadPtr,uint16_t length,uint16_t* realReadByteCount)
{
    //ADT系统锁定前置
    ADT_SYS_LOCK_ALLOC(lastState);
    uint16_t readCount = 0;
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtr,ADT_CircularWordQueueReadBuffer);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueReadBuffer,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    if(bufferReadPtr == NULL)
    {
        ADT_SHOW_STR(circularWordQueuePtr,"Error!! ADT_CircularWordQueueReadBuffer bufferReadPtr NULL!!\r\n");
        *realReadByteCount = 0;
        return;
    }
    //系统锁定
    ADT_SYS_LOCK(circularWordQueuePtr);
    if(0 == circularWordQueuePtr->currentSize)
    {
        *realReadByteCount = 0;
    }
    else
    {
        while(circularWordQueuePtr->currentSize > 0)
        {
            bufferReadPtr[readCount++] = circularWordQueuePtr->queueArrayBuffer[circularWordQueuePtr->frontPos++];
            circularWordQueuePtr->frontPos %= circularWordQueuePtr->maxSize;
            circularWordQueuePtr->currentSize--;
            if(readCount == length)
            {
                break;
            }
        }
        *realReadByteCount = readCount;
    }
    //系统解锁
    ADT_SYS_UNLOCK(circularWordQueuePtr);
    return;
}

//从循环队列中读取单个字数据
ADT_RESULT ADT_CircularWordQueueReadOnce(ADT_T circularByteQueuePtr,uint16_t* readBytePtr)
{
    uint16_t readReadCount = 0;
    ADT_CircularWordQueueReadBuffer(circularByteQueuePtr,readBytePtr,1,&readReadCount);
    if(readReadCount == 0)
    {
        return ADT_RESULT_FAIL;
    }
    return ADT_RESULT_OK;
}

//清空队列
void ADT_CircularWordQueueClear(ADT_T circularWordQueuePtr)
{
    //ADT系统锁定前置
    ADT_SYS_LOCK_ALLOC(lastState);
    //指针检查
    ADT_BASE_PTR_CHECK(circularWordQueuePtr,ADT_CircularWordQueueClear);
    //ID检查
    ADT_BASE_ID_CHECK(circularWordQueuePtr,ADT_CircularWordQueueClear,ADT_CIRCULAR_WORD_QUEUE_T_ID);
    //系统锁定
    ADT_SYS_LOCK(circularWordQueuePtr);
    circularWordQueuePtr->frontPos = 0;
    circularWordQueuePtr->rearPos = 0;
    circularWordQueuePtr->currentSize = 0;
    //系统解锁
    ADT_SYS_UNLOCK(circularWordQueuePtr);
    return;
}

