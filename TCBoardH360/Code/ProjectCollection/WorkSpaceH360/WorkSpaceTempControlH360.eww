<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\H360_NetTCBoard18\ProjectFiles\H360_NetTCBoard18.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Boot\ProjectFiles\TCBoardH360_Boot.ewp</path>
    </project>
    <batchBuild />
</workspace>
