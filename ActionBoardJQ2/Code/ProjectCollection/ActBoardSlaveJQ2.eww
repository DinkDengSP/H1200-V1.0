<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AppDemo\ProjectFiles\ActBoardSlaveJQ2_AppDemo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Boot\ProjectFiles\ActBoardSlaveJQ2_Boot.ewp</path>
    </project>
    <batchBuild />
</workspace>
